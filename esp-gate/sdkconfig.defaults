## esp-gate/sdkconfig.defaults
```kconfig
# Gate-only defaults — mDNS must be enabled so mdns_node.c links.
CONFIG_ENABLE_MDNS=y
```
